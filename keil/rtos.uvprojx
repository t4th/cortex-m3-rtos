# Keil uVision project rtos.uvprojx, settings and files
target stm32f103ze (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtos
  c flags: Optim=4 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c misc: -fno-exceptions
  c include: ..\external\arm;..\external\st\STM32F10x;..\source\kernel;..\source\kernel\common;..\source\kernel\critical_section;..\source\kernel\event;..\source\kernel\handle;..\source\kernel\scheduler;..\source\kernel\task;..\source\kernel\timer;..\source\kernel\hardware;..\source\kernel\system_timer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../source/main/: main.cpp
  group kernel
    ../source/kernel/: kernel.cpp
    ../source/kernel/timer/: timer.cpp
    ../source/kernel/task/: task.cpp
    ../source/kernel/scheduler/: scheduler.cpp
    ../source/kernel/event/: event.cpp
    ../source/kernel/critical_section/: critical_section.cpp
  group hardware
    ../source/kernel/hardware/armv7m/: hardware.cpp
  group startup
    ../external/st/STM32F10x/: startup_stm32f10x_hd.s system_stm32f10x.c
  group common
    ../source/kernel/common/: assert.cpp
  group doc
    ../: LICENSE.txt README.md
