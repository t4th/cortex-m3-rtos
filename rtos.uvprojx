# Keil uVision project rtos.uvprojx, settings and files
target stm32f103ze (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x40000000 size 0x47ffffff
  group Source Group 1
    src/: main.c gpio.c arbiter.c
    ./src/: kernel.c timer.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
