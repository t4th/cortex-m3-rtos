# Keil uVision project rtos.uvprojx, settings and files
target stm32f103ze (6210000::V6.21::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: create_task_example.elf
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: STM32F103xE
  c misc: -fno-exceptions
  c include: ..\..\..\source\;..\..\..\external\arm;..\..\..\external\st\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../: main.cpp
  group kernel
    ../../../source/: kernel.cpp
  group armv7-m
    ../../../source/hardware/armv7m/: hardware.cpp
  group external
    ../../../external/st/STM32F10x/armcc/: startup_stm32f10x_hd.s
    ../../../external/st/STM32F10x/: system_stm32f1xx.c
